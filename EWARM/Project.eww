<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bootloader_stm32f103C8.ewp</path>
  </project>
  <batchBuild />
</workspace>
